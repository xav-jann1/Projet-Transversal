<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FTC_07A.ewp</path>
  </project>
  <batchBuild />
</workspace>
